options:
  parameters:
    author: domen
    generate_options: qt_gui
    id: NOAA_listener
    output_language: python
    title: NOAA satelite listener
  states: {}

blocks:
- name: SampleRate
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: WavOutName
  id: variable
  parameters:
    value: '"H:/Projects/NOAA_listener/Data/" + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: '"Contrast"'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '100'
    stop: '50000'
    value: '10000'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: H:\Projects\MeteorM2 listener\GNURadio\test\good_og.wav
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: WavOutName
    samp_rate: samp_rate
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: SampleRate/samp_rate*2
    type: fff
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:65443
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [analog_rail_ff_0, '0', qtgui_sink_x_0_0, '0']
- [audio_source_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', analog_rail_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_uchar_0, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_wavfile_sink_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_0, '0']
- [pfb_arb_resampler_xxx_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
