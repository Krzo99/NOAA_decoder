options:
  parameters:
    author: domen
    generate_options: qt_gui
    id: NOAA_listener
    output_language: python
    title: NOAA satelite listener
  states: {}

blocks:
- name: BaudRate
  id: variable
  parameters:
    value: '4160'
  states: {}
- name: Contrast
  id: variable
  parameters:
    value: '300'
  states: {}
- name: SampleRate
  id: variable
  parameters:
    value: 4*BaudRate
  states: {}
- name: SeletedSatFreq
  id: variable
  parameters:
    comment: NOAA 15
    value: '137620000'
  states: {}
- name: SeletedSatFreq
  id: variable
  parameters:
    comment: NOAA 18
    value: '137912500'
  states: {state: disabled}
- name: SeletedSatFreq
  id: variable
  parameters:
    comment: NOAA 19
    value: '137100000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: '"Frequency shift:"'
    min_len: '1000'
    orient: Qt.Horizontal
    rangeType: int
    start: SeletedSatFreq-10000
    step: '1'
    stop: SeletedSatFreq+10000
    value: SeletedSatFreq
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: H:\Projects\MeteorM2 listener\GNURadio\test\good_og.wav
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Contrast
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: F:\Downloads\backupRecording.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4160'
    decim: '1'
    gain: '1'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: SampleRate/samp_rate
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: BaudRate/SampleRate
    type: fff
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: variable_qtgui_range_0
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:65443
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_1, '1', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_mag_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_uchar_0, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_1, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', hilbert_fc_0, '0']
- [pfb_arb_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', analog_rail_ff_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
